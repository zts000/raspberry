# Keil uVision project MAX6675.uvproj, settings and files
target Target 1 (MCS-51)
  device: 89C52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(24000000)
  output: MAX6675 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: K型热电偶MAX6675测温程序.c
